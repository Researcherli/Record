# Keil uVision project FreeRTOS.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F470VI GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.0.3
  cpu: IRAM(0x20000000,0x0B0000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x0200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: FreeRtos
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: GD32F470,HXTAL_VALUE=8000000
  c include: .\CMSIS;.\CMSIS\GD;.\CMSIS\GD\GD32F4xx;.\CMSIS\GD\GD32F4xx\Include;.\FWLIB;.\FWLIB\Include;.\Project;.\User;.\App;.\FreeRTOS;.\FreeRTOS\inc;.\FreeRTOS\port\RVDS\ARM_CM4F;.\FreeRTOS\port\MemMang;.\Driver
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0xb0000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Driver
    ./Driver/: Usart.c
  group User
    ./User/: main.c systick.c gd32f4xx_it.c
  group CMSIS
    ./CMSIS/GD/GD32F4xx/Include/: gd32f4xx.h system_gd32f4xx.h
    ./CMSIS/: core_cm4.h
    ./CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
    ./CMSIS/GD/GD32F4xx/Source/ARM/: startup_gd32f450_470.s
  group FWLIB
    ./FWLIB/Source/: gd32f4xx_adc.c gd32f4xx_can.c gd32f4xx_crc.c gd32f4xx_ctc.c gd32f4xx_dac.c gd32f4xx_dbg.c gd32f4xx_dci.c gd32f4xx_dma.c gd32f4xx_enet.c gd32f4xx_exmc.c gd32f4xx_exti.c gd32f4xx_fmc.c gd32f4xx_fwdgt.c gd32f4xx_gpio.c gd32f4xx_i2c.c gd32f4xx_ipa.c gd32f4xx_iref.c gd32f4xx_misc.c gd32f4xx_pmu.c gd32f4xx_rcu.c gd32f4xx_rtc.c gd32f4xx_sdio.c gd32f4xx_spi.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_tli.c gd32f4xx_trng.c gd32f4xx_usart.c gd32f4xx_wwdgt.c
  group FreeRTOS_Src
    ./FreeRTOS/src/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group FreeRTOS_Port
    ./FreeRTOS/port/RVDS/ARM_CM4F/: port.c
    ./FreeRTOS/port/MemMang/: heap_4.c
